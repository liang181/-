# Keil uVision project campic.uvproj, settings and files
target AT89C52 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: campic +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: _main.c myfun.c sdx.c uart.c sccb.c Sensor.c fifo.c
    ./znFAT/: deviceio.c znFAT.c
